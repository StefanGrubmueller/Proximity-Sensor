# Keil uVision project proximity.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proximity
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c
  group source
    ./: proximity.c proximity.h
  group lib
    ./: i2c.c i2c.h armv10_std.h
    $TC_ROOT$/../../Users/stefa/Documents/Schule/4BHEL/DIC/sparkfun/proximity/: I2Clib.lib
software components: CMSIS:CORE 5.3.0, HTL Hollabrunn:Libraries:STDLib 2.0.0, Device:Startup 1.0.0
